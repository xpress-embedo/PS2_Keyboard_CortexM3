# IAR project PS2_Keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; Drivers; Drivers\include; Drivers\source; LPC13xx; LPC13xx\Include; LPC13xx\Source; LPC13xx\Source\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PS2_Keyboard.srec
  ILINK.IlinkOutputFile: PS2_Keyboard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: config.c lcd_16x2.c main.c ps2_keyboard.c
  group CMSIS-CM3
    LPC13xx/Source/: system_LPC13xx.c
  group Drivers
    Drivers/source/: lpc13xx_gpio.c
  group Startup
    LPC13xx/Source/IAR/: startup_LPC13xx.s
